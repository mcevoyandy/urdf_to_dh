Commit message: wip

File: urdf/random.urdf (robot description, URDF)
Before this commit: robot randombot, 8 links, 7 joints
Joints:
- joint joint0: axis 0.6882854605711649 0.36375525034206413 0.6276505736593584 -> 1 0 0
- joint joint5: parent link5 -> link3
